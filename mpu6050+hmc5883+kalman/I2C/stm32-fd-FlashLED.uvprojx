# Keil uVision project stm32-fd-FlashLED.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-FD-FLASHLED +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\user;.\CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ./startup/: startup_stm32f10x_hd.s
  group USR
    ./user/: main.c HMC5883.c USART.c I2C.c DELAY.c MPU6050.c
  group FWlib
    ./FWlib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group CMSYS
    ./CM3/: core_cm3.c system_stm32f10x.c
  group readme
    ./user/: readme.txt
software components: CMSIS:CORE 4.2.0
