# Keil uVision project Project.uvprojx, settings and files
target STM32F429_439xx (ARM-ADS)
  device: STM32F439NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429_439xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM324x9I_EVAL
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM324x9I_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dcmi.c stm32f4xx_qspi.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_cryp_tdes.c stm32f4xx_dma2d.c stm32f4xx_sdio.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cec.c stm32f4xx_wwdg.c stm32f4xx_sai.c stm32f4xx_crc.c stm32f4xx_exti.c stm32f4xx_hash_sha1.c stm32f4xx_dbgmcu.c stm32f4xx_fmpi2c.c stm32f4xx_rng.c stm32f4xx_hash.c stm32f4xx_pwr.c stm32f4xx_dsi.c misc.c stm32f4xx_flash.c stm32f4xx_usart.c stm32f4xx_cryp.c stm32f4xx_lptim.c stm32f4xx_dac.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_i2c.c stm32f4xx_hash_md5.c stm32f4xx_dma.c stm32f4xx_ltdc.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_iwdg.c stm32f4xx_fsmc.c stm32f4xx_spdifrx.c stm32f4xx_fmc.c
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group user
    ../: stm32f4xx_it.c
    ./user/: main.c sensor_bar.c imu_targeting.c buzzer_song.c menu.c servo_interface.c sb_cali.c MTi_adp.c coord.c velocity.c comm.c
  group core
    ./core/: adc.c MTi-1_UART.c approx_math.c can_protocol.c encoder.c button.c lcd_main.c led.c tm_stm32f4_gpio.c tm_stm32f4_i2c.c tm_stm32f4_stdio.c usart.c buzzer.c quick_math.c servo.c tm_stm32f4_timer_properties.c angle_range.c vector_math.c
    ./user/: adc_ir.c
    ./: ticks.c
  group path
    ./user/: path.h path_station.c path_downslope.c path_down_imu.c path_upslope_imu.c path_river.c path_river_new.c path_upslope_sb.c
target STM32F427_437xx (ARM-ADS)
  device: STM32F437IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F427_437xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,USE_STM324x7I_EVAL
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM324x7I_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
target STM32F40_41xxx (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F40_41xxx +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --C99
  c include: .\core;.\user;..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
target STM32F401xx (ARM-ADS)
  device: STM32F401VCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
target STM32F411xE (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F411xE
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
target STM32F446xx (ARM-ADS)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: as above
  output: STM32F446xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F446xx
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
target STM32F469_479xx (ARM-ADS)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F469_479xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F469_479xx
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
target STM32F410xx (ARM-ADS)
  device: STM32F410RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F410xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F410xx
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.2.0
