# Keil uVision project Project.uvprojx, settings and files
target stm32_template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_template +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_XL, USE_STM3210B_EVAL
  c include: .\src;.\src\stm32f10x_std\inc;.\src\ustrobo_min_system\inc;.\src\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group src
    ./src/ustrobo_min_system/src/: battery.c
    ./src/user/: main.c can_protocol.c can.c can_motor.c bluetooth.c crc.c button.c line_sensor.c bluetooth_xbc_mb.c can_xbc_mb.c xbc_mb.c pneumatic.c manual_mode.c auto_mode.c xbc_control.c robot_control.c pca9685.c laser_sensor.c manual_track.c semi_auto.c adc_ir.c buzzer_song.c quick_math.c acc_module.c climbing.c RPM_sensor.c
  group ustrobo
    ./src/ustrobo_min_system/src/: approx_math.c delay.c gyro.c motor_pwm.c linear_ccd.c servo.c ticks.c uart.c xbc_mb.c led.c gpio.c encoder.c lcd_main.c adc.c buzzer.c
  group stm32f10x_std
    ./src/stm32f10x_std/src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c stm32f10x_it.c
  group stm32f10x_startup
    ./src/stm32f10x_startup/: startup_stm32f10x_hd.s startup_stm32f10x_md.s startup_stm32f10x_xl.s
