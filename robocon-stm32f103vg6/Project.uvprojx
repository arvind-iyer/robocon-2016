# Keil uVision project Project.uvprojx, settings and files
target stm32_template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VF STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0xC0000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_template +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_XL, USE_STM3210B_EVAL, MAINBOARD_V4
  c include: .\src;.\src\stm32f10x_std\inc;.\src\ustrobo_min_system\inc;.\src\user;.\src\ustrobo_min_system\src;.\src\ustrobo_min_system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group src
    ./src/user/: buzzer_song.c main.c robocon.c wheel_base_pid.c wheel_base.c special_char_handler.c log.c send_debug_data.c flash.c
  group ustrobo
    ./src/ustrobo_min_system/src/: approx_math.c bluetooth.c button.c buzzer.c can_motor.c can_protocol.c crc.c delay.c encoder.c gpio.c gyro.c interface.c led.c motor_pwm.c servo.c system_test.c tft.c ticks.c usart.c xbc_mb.c bluetooth_xbc_mb.c can_xbc_mb.c mb1240.c adc.c adc_app.c nec.c nec_remote.c nec_mb.c ultrasonic_mb.c
  group stm32f10x_std
    ./src/stm32f10x_std/src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group stm32f10x_startup
    ./src/stm32f10x_startup/: startup_stm32f10x_hd.s startup_stm32f10x_md.s startup_stm32f10x_xl.s
  group pk
    ./src/user/pk/: pk.c pk_brushless.c pk_manual.c pk_movement.c pk_pid.c pk_positioning.c
