# Keil uVision project Project.uvprojx, settings and files
target can_xbc (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: can_xbc +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: .\src;.\src\stm32f10x_std\inc;.\src\ustrobo_min_system\inc;.\src\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/user/: buzzer_song.c robocon.c main.c ch376_driver.c wheel_base.c wheel_base_pid.c system.c usb_api.c xbc.c interface.c
  group ustrobo
    ./src/ustrobo_min_system/src/: approx_math.c battery.c bluetooth.c button.c buzzer.c can_motor.c can_protocol.c crc.c delay.c encoder.c gpio.c gyro.c interface.c led.c motor_pwm.c servo.c system_test.c tft.c ticks.c uart.c ultrasonic.c usart.c xbc_mb.c
  group stm32f10x_std
    ./src/stm32f10x_std/src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group stm32f10x_startup
    ./src/stm32f10x_startup/: startup_stm32f10x_hd.s startup_stm32f10x_md.s startup_stm32f10x_xl.s
