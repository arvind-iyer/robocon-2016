# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c led.c ticks.c servo.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.80.0, Device:STM32Cube HAL:ADC 1.4.2, Device:STM32Cube HAL:CAN 1.4.2, Device:STM32Cube HAL:CRC 1.4.2, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DAC 1.4.2, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:Flash 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:HCD 1.4.2, Device:STM32Cube HAL:I2C 1.4.2, Device:STM32Cube HAL:I2S 1.4.2, Device:STM32Cube HAL:IRDA 1.4.2, Device:STM32Cube HAL:IWDG 1.4.2, Device:STM32Cube HAL:NAND 1.4.2, Device:STM32Cube HAL:NOR 1.4.2, Device:STM32Cube HAL:PC Card 1.4.2, Device:STM32Cube HAL:PCD 1.4.2, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:RCC 1.4.2, Device:STM32Cube HAL:RNG 1.4.2, Device:STM32Cube HAL:RTC 1.4.2, Device:STM32Cube HAL:SD 1.4.2, Device:STM32Cube HAL:SPI 1.4.2, Device:STM32Cube HAL:SRAM 1.4.2, Device:STM32Cube HAL:Smartcard 1.4.2, Device:STM32Cube HAL:TIM 1.4.2, Device:STM32Cube HAL:UART 1.4.2, Device:STM32Cube HAL:USART 1.4.2, Device:STM32Cube HAL:WWDG 1.4.2, Device:Startup 2.4.2
