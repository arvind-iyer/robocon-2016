# Keil uVision project project.uvprojx, settings and files
target STM32F4_ROBOCON (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project.hex +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F4XX,USE_STM32F405VG
  c include: .\inc;..\STM32F4xx_StdPeriph_Driver;..\STM32F4xx_StdPeriph_Driver\inc;..\Device\ST\STM32F4xx;..\Device\ST\STM32F4xx\Include;..\Project;.\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --show_parent_lib --show_full_path
  group MAIN_SOURCE
    ./src/: led.c main.c approx_math.c buzzer.c buzzer_song.c can_motor.c can_protocol.c encoder.c gyro.c infrared_sensor.c lcd.c line_sensor.c sensor_bar.c tm_stm32f4_delay.c tm_stm32f4_gpio.c tm_stm32f4_i2c.c tm_stm32f4_pwm.c tm_stm32f4_servo.c tm_stm32f4_stdio.c tm_stm32f4_timer_properties.c usart.c
  group INCLUDE
    ./inc/: led.h main.h approx_math.h attributes.h buzzer.h buzzer_song.h can_motor.h can_protocol.h defines.h encoder.h gyro.h infrared_sensor.h lcd.h lcd_font.h line_sensor.h sensor_bar.h tm_stm32f4_delay.h tm_stm32f4_gpio.h tm_stm32f4_i2c.h tm_stm32f4_pwm.h tm_stm32f4_servo.h tm_stm32f4_stdio.h tm_stm32f4_timer_properties.h usart.h
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.4.2
